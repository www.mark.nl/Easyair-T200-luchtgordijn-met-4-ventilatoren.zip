Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-04-15T15:40:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 15 15:40:01 2021 * Host: GVIZITI-RO-LE * Database: C:\Users\gviziti\AppData\Local\Temp\{8FBC3E27-8823-4623-AEB7-847109BF4AD9}\ifc * Database version: 5507 * Database creation date: Thu Apr 15 15:39:59 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Apr 15 15:40:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 15 15:40:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcAirTerminal: T200 4 fans High/Low, HC_Air Curtain_MEPcontent_Mark_Easyair_T200 4 fans_INT-EN:T200 4 fans High/Low:1299698
In: F00
Type - Material: Color RGB 193-193-194
Type - Dimensions - Height: 850 mm; Length: 3000 mm; Weight: 130; Width: 584 mm
Type - Electrical Engineering - Current: 2.68 A; Voltage: 400 V
Type - Identity Data - Article Description: Recirculation air curtain; Article Type: T200 4 fans High/Low; Base Family Version: 12.26; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Recirculation air curtain; EMCS Version: 4.0; ETIM Article Class: EC010067; Family Version: 12.26; GLN: 8719333004471; GTIN: 8720211954160; Manufacturer: Mark; Manufacturer Art. No.: 5063021; Manufacturer URL: https://www.markclimate.com/air-heating/air-curtains/easyair-t200/; MEPcontent Class: AIR_CURTAIN; Model: T200 4 fans High/Low; OmniClass Number: 23.75.35.17.21; OmniClass Title: Air Curtains; Product Line: Easyair; Revit Version: 2018; Type Name: T200 4 fans High/Low; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Light Grey: Color RGB 193-193-194
Type - Mechanical - Air Displacement: 4.13889 m3/s
Type - Other - Category: Mechanical Equipment; Control Box Visibility: no; Family Name: HC_Air Curtain_MEPcontent_Mark_Easyair_T200 4 fans_INT-EN; Hight/Low Visibility: yes
Type - Pset_AirTerminalTypeCommon - Reference: T200 4 fans High/Low
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 5.69509 m2; Mounting Height: 4000 mm; Volume: 0.774326 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - System Classification: Power
Other - Family: HC_Air Curtain_MEPcontent_Mark_Easyair_T200 4 fans_INT-EN: T200 4 fans High/Low; Family and Type: HC_Air Curtain_MEPcontent_Mark_Easyair_T200 4 fans_INT-EN: T200 4 fans High/Low; Offset Safe: 4000 mm; Type: HC_Air Curtain_MEPcontent_Mark_Easyair_T200 4 fans_INT-EN: T200 4 fans High/Low; Type Id: HC_Air Curtain_MEPcontent_Mark_Easyair_T200 4 fans_INT-EN: T200 4 fans High/Low
Phasing - Phase Created: 4. Plan over 10 years
